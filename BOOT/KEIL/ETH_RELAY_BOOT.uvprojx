# Keil uVision project ETH_RELAY_BOOT.uvprojx, settings and files
target BOOT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ETH_RELAY_BOOT +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L
  c flags: Optim=3 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: ..\..\CMSIS\inc;..\SOURCE\inc;..\..\LIB\lan8720\inc
  asm include: ..\..\CMSIS\inc;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../CMSIS/StartUp/: startup_stm32f40_41xxx.s
    ../../CMSIS/src/: system_stm32f4xx.c
  group LIB
    ../../LIB/lan8720/src/: lan87xxa.c stm32f4xx_eth.c
  group Source
    ../SOURCE/src/: main.c sysInit.c
